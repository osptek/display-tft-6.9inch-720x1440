#include "st7121p_lcd.h"

#include "esp_lcd_panel_io.h"
#include "esp_log.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

static const char *TAG = "st7121p";

typedef struct {
    uint8_t cmd;
    const uint8_t *data;
    size_t data_len;
    uint16_t delay_ms;
} st7121p_cmd_t;

static const uint8_t s_cmd_02[] = {0x71, 0x21, 0xA2};
static const uint8_t s_cmd_03[] = {0x71, 0x21, 0xA3};
static const uint8_t s_cmd_04[] = {0x71, 0x21, 0xA4};
static const uint8_t s_cmd_05[] = {0x21};
static const uint8_t s_cmd_06[] = {0xEF};
static const uint8_t s_cmd_07[] = {0x00, 0x00, 0x64, 0x64, 0x44, 0x1A};
static const uint8_t s_cmd_08[] = {0x22, 0x61, 0x11, 0x7A, 0x25, 0x2F, 0x2F};
static const uint8_t s_cmd_09[] = {0x93, 0x93};
static const uint8_t s_cmd_10[] = {0x31};
static const uint8_t s_cmd_11[] = {0xF0, 0x03};
static const uint8_t s_cmd_12[] = {0x10, 0x1B, 0x3B, 0x2A, 0xD0, 0xD0};
static const uint8_t s_cmd_13[] = {0x71, 0x23, 0x5A, 0x20, 0x24, 0x11, 0x21};
static const uint8_t s_cmd_14[] = {0x80, 0x01, 0x88, 0x30, 0x45, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x1E, 0x5C, 0x1E, 0x80, 0x00, 0x4F, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x1E, 0x5C, 0x1E, 0x80, 0x00, 0xEF, 0x58, 0x00, 0x00, 0x00, 0xFF};
static const uint8_t s_cmd_15[] = {0x00, 0x00, 0x24, 0x77, 0x25, 0x00, 0x26, 0x00, 0x56, 0x56, 0x91, 0xFF, 0x00, 0x24, 0x77, 0x25, 0x00, 0x26, 0x00, 0x56, 0x56, 0x91, 0xFF, 0x00, 0x24, 0x77, 0x2D, 0x00, 0x2E, 0x00, 0x56, 0x56, 0x91, 0xFF, 0x00, 0x2C, 0x77, 0x00, 0x00, 0x00, 0x00, 0x56, 0x56, 0xFF, 0xFF, 0x00, 0x08, 0x80, 0x08, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00};
static const uint8_t s_cmd_16[] = {0x14, 0x14, 0xC0, 0x64, 0x40, 0x0B, 0x1A, 0x40, 0x00, 0x46, 0x05, 0x56, 0x56, 0x91, 0xFF, 0x08, 0x80, 0x64, 0x40, 0x29, 0x38, 0x40, 0x00, 0x04, 0x03, 0x56, 0x56, 0x91, 0xFF, 0x08, 0x80, 0x64, 0x40, 0x47, 0x56, 0x40, 0x00, 0x02, 0x01, 0x56, 0x56, 0x91, 0xFF, 0x08, 0x80, 0x64, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x56, 0x56, 0x91, 0xFF, 0x08, 0x80, 0x75};
static const uint8_t s_cmd_17[] = {0x1D, 0x18, 0x19, 0x1D, 0x1D, 0x1C, 0x1D, 0x1A, 0x1B, 0x1D, 0x00, 0x02, 0x1C, 0x1C, 0x1C, 0x04, 0x11, 0x13, 0x15, 0x0C, 0x0A, 0x08, 0x1D, 0x18, 0x19, 0x1D, 0x1D, 0x1B, 0x1A, 0x1C, 0x1C, 0x1D, 0x01, 0x03, 0x1C, 0x1C, 0x1C, 0x05, 0x10, 0x12, 0x14, 0x0D, 0x0B, 0x09};
static const uint8_t s_cmd_18[] = {0x0C, 0x40, 0x46, 0x00, 0x07, 0x4B, 0x4B, 0xFF, 0xFF, 0xF0, 0x40, 0x0E, 0x01, 0x07, 0x42, 0x42, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF};
static const uint8_t s_cmd_19[] = {0x80, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0x00};
static const uint8_t s_cmd_20[] = {0x15, 0x19, 0x05, 0x23, 0x49, 0x2D, 0x03, 0x2E, 0x5C, 0xD2, 0xFF, 0x10, 0x60, 0xFD, 0x20, 0xC0, 0x00};
static const uint8_t s_cmd_21[] = {0x20, 0x60, 0x04, 0x7C, 0x7C, 0x3E, 0x04, 0xDC, 0xDC, 0x3E, 0x06, 0xFA, 0x26, 0x3E};
static const uint8_t s_cmd_22[] = {0x03, 0x04};
static const uint8_t s_cmd_23[] = {0x4B, 0x00, 0x00, 0xBE, 0x4B, 0x8C, 0x20, 0x1A, 0xF0, 0x7D, 0x14, 0x7D, 0x14, 0x7D, 0x14, 0x7D, 0x14, 0xFF, 0x00, 0x32, 0x30, 0x73, 0x00, 0x00, 0xC8, 0x6A, 0xFF, 0x5A, 0x64, 0x38, 0x88, 0x15, 0xB1, 0x01, 0x01, 0x64, 0x01, 0x01, 0x7C, 0xFF, 0x1A, 0x51};
static const uint8_t s_cmd_24[] = {0x0C, 0x0C};
static const uint8_t s_cmd_25[] = {0x15, 0x00, 0x01};
static const uint8_t s_cmd_26[] = {0x00, 0x00, 0x29, 0x3D, 0x6A, 0x10, 0xAD, 0x06, 0x01, 0x06, 0x11, 0x66, 0x09, 0xE9, 0x02, 0x22, 0x40, 0x0F, 0x85, 0x0E, 0x32, 0xC7, 0x0D, 0x19, 0x09, 0x33, 0x8F, 0x05, 0xD2, 0x0E, 0xF3, 0xF0, 0x02, 0xFA, 0xFF, 0x03, 0xFF};
static const uint8_t s_cmd_27[] = {0x00, 0x00, 0x29, 0x3D, 0x6A, 0x10, 0xAD, 0x06, 0x01, 0x06, 0x11, 0x66, 0x09, 0xE9, 0x02, 0x22, 0x40, 0x0F, 0x85, 0x0E, 0x32, 0xC7, 0x0D, 0x19, 0x09, 0x33, 0x8F, 0x05, 0xD2, 0x0E, 0xF3, 0xF0, 0x02, 0xFA, 0xFF, 0x03, 0xFF};
static const uint8_t s_cmd_28[] = {0x71, 0x21, 0x00};

static const st7121p_cmd_t s_init_cmds[] = {
    {0x10, NULL, 0, 0},
    {0x28, NULL, 0, 0},
    {0x60, s_cmd_02, sizeof(s_cmd_02), 0},
    {0x60, s_cmd_03, sizeof(s_cmd_03), 0},
    {0x60, s_cmd_04, sizeof(s_cmd_04), 0},
    {0x78, s_cmd_05, sizeof(s_cmd_05), 0},
    {0x79, s_cmd_06, sizeof(s_cmd_06), 0},
    {0xB7, s_cmd_07, sizeof(s_cmd_07), 0},
    {0xB0, s_cmd_08, sizeof(s_cmd_08), 0},
    {0xBF, s_cmd_09, sizeof(s_cmd_09), 0},
    {0xA4, s_cmd_10, sizeof(s_cmd_10), 0},
    {0xA5, s_cmd_11, sizeof(s_cmd_11), 0},
    {0xD7, s_cmd_12, sizeof(s_cmd_12), 0},
    {0x90, s_cmd_13, sizeof(s_cmd_13), 0},
    {0xA3, s_cmd_14, sizeof(s_cmd_14), 0},
    {0xA6, s_cmd_15, sizeof(s_cmd_15), 0},
    {0xA7, s_cmd_16, sizeof(s_cmd_16), 0},
    {0xAC, s_cmd_17, sizeof(s_cmd_17), 0},
    {0xAD, s_cmd_18, sizeof(s_cmd_18), 0},
    {0xAE, s_cmd_19, sizeof(s_cmd_19), 0},
    {0xB2, s_cmd_20, sizeof(s_cmd_20), 0},
    {0xE8, s_cmd_21, sizeof(s_cmd_21), 0},
    {0x75, s_cmd_22, sizeof(s_cmd_22), 0},
    {0xE7, s_cmd_23, sizeof(s_cmd_23), 0},
    {0xE1, s_cmd_24, sizeof(s_cmd_24), 0},
    {0xEA, s_cmd_25, sizeof(s_cmd_25), 0},
    {0xC8, s_cmd_26, sizeof(s_cmd_26), 0},
    {0xC9, s_cmd_27, sizeof(s_cmd_27), 0},
    {0x60, s_cmd_28, sizeof(s_cmd_28), 0},
    {0x11, NULL, 0, 120},  /* Sleep Out */
    {0x29, NULL, 0, 20},   /* Display On */
};

esp_err_t st7121p_send_init(esp_lcd_panel_io_handle_t io)
{
    for (size_t i = 0; i < sizeof(s_init_cmds) / sizeof(s_init_cmds[0]); i++) {
        const st7121p_cmd_t *cmd = &s_init_cmds[i];
        esp_err_t ret = esp_lcd_panel_io_tx_param(io, cmd->cmd, cmd->data, cmd->data_len);
        if (ret != ESP_OK) {
            ESP_LOGE(TAG, "cmd 0x%02X failed: %s", cmd->cmd, esp_err_to_name(ret));
            return ret;
        }
        if (cmd->delay_ms) {
            vTaskDelay(pdMS_TO_TICKS(cmd->delay_ms));
        }
    }
    ESP_LOGI(TAG, "init sequence done");
    return ESP_OK;
}
